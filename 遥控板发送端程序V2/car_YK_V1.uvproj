# Keil uVision project car_YK_V1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: car_YK_V1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./src/: main.c nokia_5110.c delay.c led.c interrupt.c key_scan.c nrf24L01.c ad_get.c iic.c mpu6050.c uart.c
